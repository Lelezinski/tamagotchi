# Keil uVision project sample.uvprojx, settings and files
target Default (5060960::V5.06 update 7 (build 960)::.\ARMCLANG5)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sample
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: SIMULATOR
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group SoC_Libs
    ./Board/: core_cm3.c system_LPC17xx.c
  group RIT
    ./Board/RIT/: IRQ_RIT.c lib_RIT.c RIT.h
  group Timers
    ./Board/Timers/: IRQ_timer.c lib_timer.c timer.h
  group Joystick
    ./Board/Joystick/: joystick.h lib_joystick.c
  group GLCD
    ./Board/GLCD/: AsciiLib.c AsciiLib.h GLCD.c GLCD.h
  group ADC
    ./Board/ADC/: adc.h IRQ_adc.c lib_adc.c
  group TouchPanel
    ./Board/TouchPanel/: TouchPanel.c TouchPanel.h
  group Startup
    ./: main.c startup_LPC17xx.s utils.h utils.c
software components: CMSIS:CORE 5.4.0
